# Keil uVision project uCOS-III.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uCOS-III
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,USE_FULL_ASSERT,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --gnu -DHIGHLY_OPTIMIZE -DMEMORY_OPTIMIZATION -DMLMEQUEUE_ALLOC_INUSE -DVENDOR_FEATURE2_SUPPORT -DAGGREGATION_SUPPORT -DPIGGYBACK_SUPPORT -DWMM_SUPPORT -DLINUX -DSYSTEM_LOG_SUPPORT -DRT28xx_MODE=STA -DCHIPSET=5572 -DCONFIG_RA_NAT_NONE -DCONFIG_STA_SUPPORT -DDBG -DDOT11_N_SUPPORT -DDOT11N_DRAFT3 -DSTATS_COUNT_SUPPORT -DLED_CONTROL_SUPPORT -DRTMP_MAC_USB -DRTMP_USB_SUPPORT -DRT2870 -DRT28xx -DRTMP_TIMER_TASK_SUPPORT -DA_BAND_SUPPORT -DRTMP_MAC_USB -DRTMP_USB_SUPPORT -DRT2870 -DRT28xx -DRT30xx -DRT35xx -DRT3572 -DRTMP_TIMER_TASK_SUPPORT -DRTMP_RF_RW_SUPPORT -DRTMP_EFUSE_SUPPORT -DA_BAND_SUPPORT -DVCORECAL_SUPPORT -DRTMP_MAC_USB -DRTMP_USB_SUPPORT -DRT30xx -DRT35xx -DRT3593 -DRT3573 -DRTMP_TIMER_TASK_SUPPORT -DRTMP_RF_RW_SUPPORT -DRTMP_EFUSE_SUPPORT -DA_BAND_SUPPORT -DDOT11N_SS3_SUPPORT -DVCORECAL_SUPPORT -DNEW_MBSSID_MODE -DRTMP_FREQ_CALIBRATION_SUPPORT -DRTMP_MAC_USB -DRT30xx -DRT33xx -DRT3070 -DRT3370 -DRT5370 -DRTMP_USB_SUPPORT -DRTMP_TIMER_TASK_SUPPORT -DRTMP_RF_RW_SUPPORT -DRTMP_EFUSE_SUPPORT -DRTMP_INTERNAL_TX_ALC -DRTMP_FREQ_CALIBRATION_SUPPORT -DVCORECAL_SUPPORT -DRTMP_TEMPERATURE_COMPENSATION -DNEW_MBSSID_MODE -DRTMP_MAC_USB -DRTMP_USB_SUPPORT -DRT30xx -DRT5572 -DRT5592 -DRTMP_RF_RW_SUPPORT -DRTMP_EFUSE_SUPPORT -DRTMP_TIMER_TASK_SUPPORT -DA_BAND_SUPPORT -DVCORECAL_SUPPORT -DRTMP_TEMPERATURE_COMPENSATION -DRTMP_FREQ_CALIBRATION_SUPPORT
  c include: ..\..\uCOS-III;..\..\BSP;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\..\uCOS-III\Source;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\BSP\ST\STM32F4xx_StdPeriph_Driver\inc;..\..\BSP\ST\CMSIS\Device\ST\STM32F4xx\Include;..\..\BSP\OS\uCOS-III;..\..\..\..\..\Ralink-WIFI\DPO_RT5572_LinuxSTA_2.6.1.3_20121022_highly_optimize\include;..\..\..\..\..\uC-Shell\Source;..\..\..\..\..\lwip-1.4.1\src\include;..\..\..\..\..\lwip-1.4.1\src\include\ipv4;..\..\..\..\..\lwip-1.4.1\port;..\..\..\..\..\lwip-1.4.1\port\Standalone;..\..\..\..\..\iperf\include;..\..\..\..\..\USB_Host_Linux_Convert\usb_host;..\..\..\..\..\USB_Host_Linux_Convert\usb_host\STM32_USB_OTG_Driver\inc;..\..\..\..\..\USB_Host_Linux_Convert\memory;..\..\..\..\..\USB_Host_Linux_Convert\object;..\App\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --verbose
  group APP
    ../: app.c os_app_hooks.c app_cfg.h lib_cfg.h os_cfg_app.h shell_cfg.h lwipopts.h
    ../App/src/: wlan.c iwlib.c iwpriv.c
    ../../../../../uC-Shell/Source/: shell.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c delay.c usb_bsp.c bsp_ser.c
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/OS/uCOS-III/: bsp_os.c
    ../../../../../USB_Host_Linux_Convert/memory/: mem_cvt.c
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC/OS-III Source
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group lwip
    ../../../../../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c timers.c udp.c tcp_out.c
    ../../../../../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../lwip-1.4.1/src/netif/: etharp.c
    ../../../../../lwip-1.4.1/port/arch/: sys_arch.c
    ../../../../../lwip-1.4.1/port/Standalone/: wlan_ethernetif.c
  group STM32F4xx Library
    ../../BSP/ST/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../BSP/ST/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group USB_Linux_Convert
    ../../../../../USB_Host_Linux_Convert/usb_host/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_linux.c usbh_stdreq.c
    ../../../../../USB_Host_Linux_Convert/object/: atomic.c complete.c fs_cvt.c kthread.c misc_cvt.c net_cvt.c sem.c tasklet.c timer.c
  group STM32_USB_OTG_Driver
    ../../../../../USB_Host_Linux_Convert/usb_host/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group rt_chips
    ../../../../../Ralink-WIFI/DPO_RT5572_LinuxSTA_2.6.1.3_20121022_highly_optimize/chips/: rt30xx.c rt3070.c rt5390.c rtmp_chip.c rt28xx.c rt33xx.c rt35xx.c rt3290.c rt3370.c rt3593.c rt5592.c
  group rt_common
    ../../../../../Ralink-WIFI/DPO_RT5572_LinuxSTA_2.6.1.3_20121022_highly_optimize/common/: action.c ba_action.c cmm_aes.c cmm_asic.c cmm_cfg.c cmm_cmd.c cmm_data.c cmm_data_usb.c cmm_info.c cmm_mac_usb.c cmm_profile.c cmm_radar.c cmm_sanity.c cmm_sync.c cmm_tkip.c cmm_wep.c cmm_wpa.c crypt_aes.c crypt_arc4.c crypt_hmac.c crypt_md5.c crypt_sha2.c ee_efuse.c ee_prom.c frq_cal.c mlme.c ps.c rt_channel.c rt_led.c rt_os_util.c rt_rf.c rtmp_init.c rtmp_init_inf.c rtmp_mcu.c rtmp_timer.c rtusb_bulk.c rtusb_data.c rtusb_dev_id.c rtusb_io.c spectrum.c eeprom.c
  group rt_os
    ../../../../../Ralink-WIFI/DPO_RT5572_LinuxSTA_2.6.1.3_20121022_highly_optimize/os/linux/: rt_linux.c rt_main_dev.c rt_profile.c rt_usb.c rt_usb_util.c sta_ioctl.c usb_main_dev.c
  group rt_rate_ctrl
    ../../../../../Ralink-WIFI/DPO_RT5572_LinuxSTA_2.6.1.3_20121022_highly_optimize/rate_ctrl/: alg_ags.c alg_legacy.c ra_ctrl.c
  group rt_sta
    ../../../../../Ralink-WIFI/DPO_RT5572_LinuxSTA_2.6.1.3_20121022_highly_optimize/sta/: assoc.c auth.c auth_rsp.c connect.c rtmp_data.c sanity.c sta_cfg.c sync.c wpa.c
  group iperf_src
    ../../../../../iperf/src/: debug.c Extractor.c gnu_getopt.c gnu_getopt_long.c Locale.c ReportCSV.c ReportDefault.c Reporter.c service.c SocketAddr.c sockets_iperf.c stdio.c tcp_window_size.c Client.cpp Launch.cpp List.cpp Listener.cpp main.cpp PerfSocket.cpp Server.cpp Settings.cpp
  group iperf_compat
    ../../../../../iperf/compat/: error.c gettimeofday.c inet_ntop.c inet_pton.c setitimer.c signal.c snprintf.c string.c Thread_iperf.c delay_iperf.cpp
